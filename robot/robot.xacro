Commit message: some code improvement

File: robot/robot.xacro (robot description, xacro)
@@ -23,5 +23,5 @@
         <box size="0.5 0.3 0.07"/>
       </geometry>
-      <material name="blue"/>
+      <material name="black"/>
     </visual>
     <!-- caster front -->
